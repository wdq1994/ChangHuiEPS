# Keil uVision project EPS_TestBench_20190620.uvproj, settings and files
target Target 1 (166/167)
  device: XC2365B-40F Infineon
  cpu: IRAM(0xF600-0xFDFF) XRAM(0xA000-0xDFFF) XRAM2(0xE00000-0xE03FFF) IROM(0xC00000-0xC0EFFF) IROM2(0xC10000-0xC4FFFF) CLOCK(80000000) MOD167 MODV2
  output: EPS_TestBench_20190620 +hex
  group Dave Files
    ./: Start_V3.A66 MAIN.c SCS.c GPT1.c GPT2.c CAN.c IO.c
